Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 5344f373-7137-476a-b6f2-fb520dba1179, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-04T08:15:07+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11153670_CH_KM7678FL:26767870_CH_11153670_KM7678FL, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Connection_Electric, <Unnamed>, z_Miele_Design_Glass Black, Default
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 800 mm; Height: 51 mm; Depth: 520 mm
Pset_BuildingElementProxyCommon - Reference: 26767870_CH_11153670_KM7678FL; sets with these values: 2
